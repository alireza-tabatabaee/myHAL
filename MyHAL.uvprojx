# Keil uVision project MyHAL.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MyHAL
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: .\HAL\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group HAL
    ./HAL/src/: STM32F303xx_GPIO.c STM32F303xx_RCC.c STM32F303xx_EXTI.c STM32F303xx_SPI.c
    ./HAL/inc/: cortex-m4.h STM32F303xx_SPI.h
  group New Group
    ./: main.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
